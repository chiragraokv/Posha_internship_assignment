Commit message: upload packages

File: src/piper_description/urdf/piper_description.urdf (robot description, URDF)
Before this commit: robot piper, 11 links, 10 joints
Links:
- removed link dummy_link
- link link2: mass 1.17 -> 1.16
Joints:
- removed joint base_to_dummy
